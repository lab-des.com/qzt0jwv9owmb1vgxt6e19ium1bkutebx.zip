Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-01-10T13:36:52
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jan 10 13:36:52 2022 * Host: Avocado-PC * Database: D:\Jocuri\TEMP\{CA061CC5-D970-42AC-BBA0-1F1C046B4CDB}\ifc * Database version: 5507 * Database creation date: Mon Jan 10 13:36:52 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jan 10 13:36:52 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jan 10 13:36:52 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Soft Work Table 71, d630, Vitra-Soft_Work_Sofa-Soft_Work_Table-71_rfa:Soft Work Table 71, d630:477481
In: Level 1
Type - Material: Light oak veneer, Basic dark powder-coated
Type - Constraints - Table Shape: 71 d630
Type - Dimensions - NominalDepth: 629.921 mm; NominalHeight: 710 mm; NominalLength: 629.682 mm
Type - General - Author: BIMStone; BIMObjectName: Vitra-Soft_Work_Sofa-Soft_Work_Table-71_rfa; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Tables; NBSReference: 45-35-86/327; ProductInformation: The Soft Work Table is not just a sofa side table – it is also specifically designed for teamwork. The slender x-shaped base, which is optionally equipped with castors or glides, allows users to sit in varied positions. The top is available in a round or boat-shaped version, at heights of 45 and 71 cm. The table can be integrated in a wide range of Soft Work configurations.; Revision: n/a; Uniclass2: Pr_40_50_21_58; Uniclass2015Description: Occasional tables; Uniclass2015Reference: Pr_40_50_21_14; Version: 1; VersionDate: 21/12/2021
Type - Identity Data - Cost: 0; Description: The Soft Work Table is not just a sofa side table – it is also specifically designed for teamwork. The slender x-shaped base, which is optionally equipped with castors or glides, allows users to sit in varied positions. The top is available in a round or boat-shaped version, at heights of 45 and 71 cm. The table can be integrated in a wide range of Soft Work configurations.; Designer: Edward Barber & Jay Osgerby; Manufacturer: Vitra; Model: Soft Work Table 71, d630; OmniClass Number: 23.40.20.14.17.24; OmniClass Title: Coffee Tables; Type Name: Soft Work Table 71, d630; URL: https://www.vitra.com/en-un/office/product/details/soft-work-table
Type - Materials and Finishes - Legs and column: Basic dark powder-coated
Type - Other - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; Category: Tables; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Years; ExpectedLife: n/a; Family Name: Vitra-Soft_Work_Sofa-Soft_Work_Table-71_rfa; Features: n/a; Finish: Table top: melamine or veneer. Base: powder-coated tubular stee; Grade: n/a; Material: Metal&Wood; ModelNumber: 21069701; ModelReference: n/a; Name: Soft_Work_Table-71; ReplacementCost: n/a; Shape: Sculptured; Size: 630x630x710 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Construction - Legs with castors: no
Dimensions - Area: 1.36958 m2; Volume: 0.308128 m3
Materials and Finishes - TableTopMaterial: Light oak veneer
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: Vitra-Soft_Work_Sofa-Soft_Work_Table-71_rfa: Soft Work Table 71, d630; Family and Type: Vitra-Soft_Work_Sofa-Soft_Work_Table-71_rfa: Soft Work Table 71, d630; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Vitra-Soft_Work_Sofa-Soft_Work_Table-71_rfa: Soft Work Table 71, d630; Type Id: Vitra-Soft_Work_Sofa-Soft_Work_Table-71_rfa: Soft Work Table 71, d630; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
